# Keil uVision project FWlib-LED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F101RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FWlib-LED
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include;.\App\stm32f10x_gpio;.\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./User/: main.c startup_stm32f10x_hd.s
  group App
    ./App/stm32f10x_gpio/: stm32f10x_gpio.c
