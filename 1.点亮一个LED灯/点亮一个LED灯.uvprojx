# Keil uVision project 点亮一个LED灯.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F101RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 点亮一个LED灯 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./: main.c stm32f10x.h startup_stm32f10x_hd.s
